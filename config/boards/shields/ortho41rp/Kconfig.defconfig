## config/boards/shields/ortho41rp/Kconfig.defconfig
```kconfig
if SHIELD_MT42

config ZMK_POINTING
  default y

config PAW3222
  default y

config ZMK_KEYBOARD_NAME
default "ortho41rp"

endif
```
